require recipes-core/images/core-image-minimal-dev.bb

DESCRIPTION = "A development image for the raspberry pi 0 w"
