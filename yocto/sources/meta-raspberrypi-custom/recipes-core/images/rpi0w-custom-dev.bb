require recipes-core/images/core-image-minimal-dev.bb

DESCRIPTION = "A development image for the raspberry pi 0 w"

ENABLE_UART = "0"

RPI_USE_U_BOOT = "1"
